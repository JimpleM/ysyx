## nemu/configs/riscv32-am_defconfig
```kconfig
CONFIG_TARGET_AM=n
# CONFIG_TRACE is not set
CONFIG_MSIZE=0x2000000
CONFIG_DEVICE=y
```
